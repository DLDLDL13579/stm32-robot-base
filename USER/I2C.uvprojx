# Keil uVision project I2C.uvprojx, settings and files
target I2C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: I2C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: ..\USER;..\CMSIS;..\FWLib\inc;..\BSP;..\BSP\Delay;..\BSP\motor_model;..\BSP\Usart1;..\BSP\Timer;C:\baidunetdiskdownload\野火小智【姿态传感器_MPU6050】模块_20240729\2-配套例程_接线说明\野火小智STM32F103C8核心板\标准库\1.打印原始寄存器数据\User\iic;C:\baidunetdiskdownload\野火小智【姿态传感器_MPU6050】模块_20240729\2-配套例程_接线说明\野火小智STM32F103C8核心板\标准库\1.打印原始寄存器数据\User\mpu6050;C:\baidunetdiskdownload\野火小智【姿态传感器_MPU6050】模块_20240729\2-配套例程_接线说明\野火小智STM32F103C8核心板\标准库\1.打印原始寄存器数据\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c AllHeader.h myenum.h
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/Delay/: delay.c
    ../BSP/: bsp.c
    ../BSP/Usart1/: usart.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/motor_model/: bsp_motor_iic.c IOI2C.c
    ./: bsp_usart.h bsp_usart.c bsp_soft_i2c.c bsp_soft_i2c.h mpu6050.h mpu6050.c
